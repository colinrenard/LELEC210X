options:
  parameters:
    author: UCLouvain
    generate_options: qt_gui
    id: decode_sdr
    output_language: python
    title: LELEC2102 - Decode SDR with FPGA
  states: {}

blocks:
- name: K_threshold
  id: variable_qtgui_range
  parameters:
    label: K factor for threshold
    orient: Qt.Horizontal
    rangeType: int
    start: '1'
    step: '1'
    stop: '254'
    value: '10'
  states: {}
- name: carrier_freq
  id: variable
  parameters:
    value: 876e6
  states: {}
- name: crc_len
  id: variable
  parameters:
    value: '1'
  states: {}
- name: data_rate
  id: variable
  parameters:
    value: 50e3
  states: {}
- name: detect_threshold
  id: variable
  parameters:
    value: '0.05'
  states: {}
- name: estimated_noise_power
  id: variable
  parameters:
    value: '4e-07'
  states: {}
- name: fdev
  id: variable
  parameters:
    value: data_rate/4
  states: {}
- name: hdr_len
  id: variable
  parameters:
    value: '8'
  states: {}
- name: melvec_length
  id: variable
  parameters:
    value: '20'
  states: {}
- name: n_melvecs
  id: variable
  parameters:
    value: '20'
  states: {}
- name: packet_len
  id: variable
  parameters:
    value: hdr_len+payload_len+crc_len
  states: {}
- name: payload_len
  id: variable
  parameters:
    value: spectrogram_len+24
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: '70'
    value: '5'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: data_rate*8
  states: {}
- name: spectrogram_len
  id: variable
  parameters:
    value: n_melvecs*melvec_length*2
  states: {}
- name: fsk_demodulation_0
  id: fsk_demodulation
  parameters:
    crc_len: crc_len
    drate: data_rate
    fdev: fdev
    fsamp: samp_rate
    payload_len: payload_len
  states: {}
- name: fsk_flag_detector_0
  id: fsk_flag_detector
  parameters:
    drate: data_rate
    enable: '1'
    fsamp: samp_rate
    packet_len: packet_len
  states: {state: disabled}
- name: fsk_packet_parser_0
  id: fsk_packet_parser
  parameters:
    address: '[0,0,1,1,1,1,1,0,0,0,1,0,1,0,1,0,0,1,0,1,0,1,0,0,1,0,1,1,0,1,1,1]'
    crc_len: crc_len
    hdr_len: hdr_len
    payload_len: payload_len
  states: {}
- name: fsk_preamble_detect_0
  id: fsk_preamble_detect
  parameters:
    drate: data_rate
    fdev: fdev
    fsamp: samp_rate
    packet_len: packet_len
    threshold: detect_threshold
  states: {}
- name: fsk_synchronization_0
  id: fsk_synchronization
  parameters:
    drate: data_rate
    estimated_noise_power: estimated_noise_power
    fdev: fdev
    fsamp: samp_rate
    hdr_len: hdr_len
    packet_len: packet_len
  states: {}
- name: limesdr_fpga_source_0
  id: limesdr_fpga_source
  parameters:
    allow_tcxo_dac: '0'
    analog_bandw_ch0: 1.5e6
    analog_bandw_ch1: 1.5e6
    calibr_bandw_ch0: 2.5e6
    calibr_bandw_ch1: 2.5e6
    ch_align: 'False'
    channel_mode: '0'
    dacVal: '180'
    digital_bandw_ch0: samp_rate
    digital_bandw_ch1: samp_rate
    dspcfg_PASSTHROUGH_LEN: (packet_len+1)*8*int(samp_rate/data_rate)+int(samp_rate/data_rate)+2000
    dspcfg_THRESHOLD: K_threshold
    dspcfg_preamble_en: '0'
    filename: ''
    gain_dB_ch0: rx_gain
    gain_dB_ch1: '1'
    lna_path_ch0: '255'
    lna_path_ch1: '2'
    nco_freq_ch0: '0'
    nco_freq_ch1: '0'
    oversample: '0'
    rf_freq: carrier_freq
    samp_rate: samp_rate
    serial: ''
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: SDR signal
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:10000
    timeout: '100'
    type: byte
    vlen: payload_len
  states: {}

connections:
- [fsk_demodulation_0, '0', fsk_packet_parser_0, '0']
- [fsk_flag_detector_0, '0', fsk_synchronization_0, '0']
- [fsk_packet_parser_0, '0', zeromq_pub_sink_0, '0']
- [fsk_preamble_detect_0, '0', fsk_synchronization_0, '0']
- [fsk_synchronization_0, '0', fsk_demodulation_0, '0']
- [limesdr_fpga_source_0, '0', fsk_flag_detector_0, '0']
- [limesdr_fpga_source_0, '0', fsk_preamble_detect_0, '0']
- [limesdr_fpga_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
