options:
  parameters:
    author: UCLouvain
    generate_options: qt_gui
    id: decode_sdr
    output_language: python
    title: LELEC2102 - Record a capture
  states: {}

blocks:
- name: carrier_freq
  id: variable
  parameters:
    value: 868e6
  states: {}
- name: data_rate
  id: variable
  parameters:
    value: 50e3
  states: {}
- name: rx_gain
  id: variable
  parameters:
    value: '20'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: data_rate*8
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/colin/LELEC210X/LELEC210X_H/telecom/hands_on_measurements/gr-fsk/data/testrecord.mat
    type: complex
  states: {}
- name: limesdr_source_0
  id: limesdr_source
  parameters:
    allow_tcxo_dac: '0'
    analog_bandw_ch0: ''
    calibr_bandw_ch0: ''
    ch_align: 'False'
    channel_mode: '0'
    gain_dB_ch0: rx_gain
    oversample: '0'
    rf_freq: carrier_freq
    samp_rate: samp_rate
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: SDR signal
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [limesdr_source_0, '0', blocks_file_sink_0, '0']
- [limesdr_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
